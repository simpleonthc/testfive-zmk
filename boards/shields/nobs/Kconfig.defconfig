## boards/shields/nobs/Kconfig.defconfig
```kconfig
if SHIELD_NOBS

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "nobs"

endif
```
